# IAR project apollo2_template.ewp, settings and files
configuration AMAPH1KK-KCR_Release (ARM, debug)
  General.OGChipSelectEditMenu: APOLLO2_1024 AmbiqMicro APOLLO2_1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APOLLO2_1024=1; APOLLO2_1024=1
  ICCARM.CCIncludePath2: ..\..\common; ..\..\example\source; ..\..\example\source\config; ..\..\library; ..\..\library\highlevel; ..\..\library\middleware; ..\..\library\lowlevel
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: apollo2_template.srec
  ILINK.IlinkOutputFile: apollo2_template.out
  ILINK.IlinkIcfFile: config\amaph1kk-kcr_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration AMAPH1KK-KCR_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ILINK.IlinkIcfFile: config\amaph1kk-kcr_ram.icf
configuration AMAPH1KK-KBR_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ILINK.IlinkIcfFile: config\amaph1kk-kbr_rom.icf
configuration AMAPH1KK-KBR_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ILINK.IlinkIcfFile: config\amaph1kk-kbr_ram.icf
  group (top)
    ../../: Readme.txt
  group common
    ../../common/: system_apollo2.c
  group source
    ../source/: main.c
    ./: startup_apollo2.s

# Keil uVision project apollo2_template.uvprojx, settings and files
target AMAPH1KK-KCR_Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x0,0x100000) IRAM1(0x10000000,0x40000) CPUTYPE"(Cortex-M4")
  output: apollo2_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO2_1024=1 APOLLO2_1024=1 APOLLO2_1024=1 APOLLO2_1024=1
  c include: ..\..\common;..\..\example\source;..\..\example\source\config;..\..\library;..\..\library\lowlevel;..\..\library\middleware;..\..\library\highlevel
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
  group common
    ../../common/: system_apollo2.c
  group source
    ../source/: main.c
    ../../: Readme.txt
    ./: startup_apollo2.s
target AMAPH1KK-KCR_Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: apollo2_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO2_1024=1 APOLLO2_1024=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
target AMAPH1KK-KBR_Debug (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: as above
  output: apollo2_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO2_1024=1 APOLLO2_1024=1 APOLLO2_1024=1 APOLLO2_1024=1
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x10020000 size 0x20000
target AMAPH1KK-KBR_Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apollo2_template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: APOLLO2_1024=1 APOLLO2_1024=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
